Commit message: Fixes for Gazebo

File: src/ydlidar_ros/urdf/ydlidar.urdf (robot description, URDF)
Before this commit: robot ydlidar_ros, 2 links, 1 joints
Joints:
- added joint base_laser_joint: type fixed, parent base_footprint, child base_laser, origin xyz=0 0 0.3 rpy=0 0 0, axis 0 0 0
